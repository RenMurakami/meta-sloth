SUMMARY = "OTA update package (.swu) for sloth-image (production)"

require sloth-swupdate.inc
