SUMMARY = "OTA update package (.swu) for sloth-image-dev (bench)"

require sloth-swupdate.inc
